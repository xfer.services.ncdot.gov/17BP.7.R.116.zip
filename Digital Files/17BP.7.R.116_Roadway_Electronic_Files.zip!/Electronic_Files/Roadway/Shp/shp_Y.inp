/* Superelevation Settings and Parameters:
 
Unit System is english.
Created input file "shp_Y.inp".
Created activity log file "shp_Y.log".
Created on Wed, Oct 04, 2017 at 10:18.
Using Preference File "rd_pref"
Using e Selection of "4%-25mph".
Using Length Selection of "all cases"
Using Design Speed of 25.000000.
 
*/
 
auto shape
job number = RDY
 
   auto shape set
      shape cluster baseline   = Y
      shape cluster profile    = PY
      shape cluster tie        = 0.0000
      dependent shape
      chain  /  offset
         Y          -10.0000
         Y          0.0000
      filler line station / slope
         10+12.000000       1.0100
         10+27.000000       0.0000
         10+42.000000      -1.0000
         10+57.000000      -2.0000
         10+95.000000      -2.0000     /* Curve Y-1 */
         11+10.000000      -2.0000     /* Curve Y-1 */
         11+25.000000      -2.0000
 
   auto shape set
      shape cluster baseline   = Y
      shape cluster profile    = PY
      shape cluster tie        = 0.0000
      dependent shape
      chain  /  offset
         Y          0.0000
         Y          10.0000
      filler line station / slope
         10+12.000000      -1.0100
         10+27.000000       0.0000
         10+42.000000       1.0000
         10+57.000000       2.0000
         10+95.000000       2.0000     /* Curve Y-1 */
         11+10.000000       1.0000     /* Curve Y-1 */
         11+25.000000       0.0000
 
   Plot Parameters
      Dependent Shape
         lvname = Prop Geopak Pavement Shape Dependent
         co = ByLevel
         lc = ByLevel
         wt = ByLevel
      Dependent Text
      lvname = Prop Geopak Pavement Shape Dependent
      co = 0
   Independent Shape
      lvname = Prop Geopak Pavement Shape Independent
      co = ByLevel
      lc = ByLevel
      wt = ByLevel
   Independent Text
      lvname = Prop Geopak Pavement Shape Independent
      co = 0
 
Write shapes into dgn = R:\Roadway\Shp\400224_rdy_shp.dgn
