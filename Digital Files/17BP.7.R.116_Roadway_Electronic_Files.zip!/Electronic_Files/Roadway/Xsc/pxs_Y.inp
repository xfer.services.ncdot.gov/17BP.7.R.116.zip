XSECTION

 PROPOSED XS

 /* >>> For english, reset the tolerance to 0.10 <<< */
 Tolerance = 0.10
    
  PATTERN DGN = R:\Roadway\Xsc\400224_rdy_pat.dgn
         PATTERN SET
         JOB NUMBER = rdy
         BASELINE = Y
         HORIZ SCALE = 10
         VERT SCALE = 10
         TYPE = line
         LVname = Pattern 2
         
  DEFINE "TM01 CONFIG" 3
  DEFINE "TM02 CONFIG" 0
  
  DEFINE "SH01 SECTION" 1
  DEFINE "SH01 WIDTH" 4
  DEFINE "SH01 SLOPE" .08
  DEFINE "SH01 PAVED" 0
  DEFINE "SH01 STANDARD CASE NUMBER" 1

  DEFINE "LD01 DITCH WIDTH" 3
  DEFINE "LD01 DITCH SLOPE" 3
  DEFINE "LD01 FIX CUT SLOPE" 2
  DEFINE "LD01 FIX FILL SLOPE" 2
  
  DEFINE "LD01 WIDEN FOR GUARDRAIL" 0
  DEFINE "LD01 WIDEN BY GUARDRAIL LINE" 1
  DEFINE "LD01 FILL SHOULDER WIDENING" 3
  DEFINE "LD01 FIX FILL SLOPE BY GUARDRAIL LINE" 0
       
  DEFINE "PAVEMENT DEPTH" 10
  DEFINE "EOP IN XSC" 0
  
  DEFINE "SLOPE TEXT HEIGHT" 1
  DEFINE "SLOPE TEXT WIDTH" 1
  DEFINE "SLOPE TEXT OFFSET" 1
  DEFINE "ELEV TEXT HEIGHT" 1
  DEFINE "ELEV TEXT WIDTH" 1
  DEFINE "ELEV TEXT OFFSET" 1
 
  DEFINE_DGN "EXIST DGN EOP"\
     DGN = R:\Roadway\xsc\400224_rdy_eop.dgn\
      type = line,line_string,arc,curve\
     lvname = Exist Roads EOP

 DEFINE_DGN "GUARDRAIL LINE"\ 
  DGN = R:\Roadway\Xsc\400224_rdy_pat.dgn\
  TYPE = line, line_string, arc, curve\ 
  LVNAME = Prop DGN Element Guardrail 

  /* >>> For english, change the extension from .met to .eng <<< */
  include L:\standard.eng

 CRITERIA FOR SHAPE CLUSTER
   SHAPE CLUSTER BASELINE = Y
   SHAPE CLUSTER PROFILE = PY
   SHAPE CLUSTER TIE = 0

 SIDE SLOPE LT where (station >= 10+12 ) and (station <= 11+50)
                 
                                                     
     include L:\tmplt01.cri
     include L:\shld01.cri
     include L:\ldss01.cri

  
 SIDE SLOPE RT where (station >= 10+12 ) and (station <= 11+50)
                  
                                         
     include L:\tmplt01.cri
     include L:\shld01.cri
     include L:\ldss01.cri
        
  SHAPE DGN = R:\Roadway\Shp\400224_rdy_shp.dgn
   SHAPE SET
    TYPE = CMP_SHAPE
    LVNAME = Prop Geopak Pavement Shape Dependent
    LVNAME = Prop Geopak Pavement Shape Independent

  XS DGN = R:\roadway\Xsc\400224_rdy_Y_xsc.dgn
   EXISTING GROUND LINE
    LVNAME = EXIST XS GROUND LINE
    TYPE = LINE,LINE_STRING

PLOT PARAMETERS
   LINE
    LVNAME ="SHAPE LEVEL"
    CO=4
    WT=1
   TEXT
    LVNAME = "SHAPE LEVEL"
    WT = 2
    CO = 0
    TH = 1
    TW = 1

PAVEMENT THICKNESS = 0.0
DO NOT FILL GAPS BETWEEN CLUSTERS
/* PROCESS CLUSTERS AS INDICATED */
WRITE XS INTO DGN= R:\roadway\Xsc\400224_rdy_Y_xsc.dgn

